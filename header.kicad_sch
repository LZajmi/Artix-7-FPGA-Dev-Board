File: header.kicad_sch (KiCad schematic)
At the start: 2 parts, among them J8 FW-10-04-G-D-100-065

Commit message: Schematic Update
Other:
- note added: "GPIO Header"
- moved on the sheet: C192, J8
