File: FPGA_dev_board.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Schematic Update
Other:
- note added: "25.09.2024"
- note added: "Artix-7 Development Board"
